# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xK GD GD32F450xK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F450; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__; USE_STDPERIPH_DRIVER; RT_USING_DLIBC; _DLIB_ADD_EXTRA_SYMBOLS; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\include; Libraries\GD32F4xx_standard_peripheral\Include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; ..\..\components\dfs\filesystems\devfs; ..\..\components\libc\posix\ipc; drivers; ..\..\components\net\lwip\lwip-2.0.3\src\include\netif; Libraries\CMSIS\GD\GD32F4xx\Include; .; ..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\libcpu\arm\cortex-m4; Libraries\CMSIS; ..\..\components\net\sal\include\dfs_net; ..\..\components\dfs\include; ..\..\components\libc\compilers\common\include; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\components\net\lwip\port; ..\..\components\finsh; ..\..\components\net\sal\include\socket\sys_socket; ..\..\components\dfs\filesystems\elmfat; ..\..\components\libc\compilers\common\extension; ..\..\components\net\sal\include; ..\..\components\net\sal\impl; ..\..\components\net\netdev\include; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; ..\..\components\net\sal\include\socket; ..\..\components\dfs\dfs_v1\include; ..\..\app\System; ..\..\app\Config; ..\..\app\CommAPI; ..\..\app\Module\Dbase; ..\..\app\System\Flag; ..\..\app\Module\Time; ..\..\app\Module\Protocol; ..\..\app\Module\Protocol\dlt645; ..\..\app\Module\Protocol\DLT698; ..\..\app\Module\Events; ..\..\app\Module\Freeze; ..\..\app\Module\SaveMem; ..\..\app\Module\Meter; ..\..\app\Fal; ..\..\app\Module\Sample; ..\..\app\System\Cpu\GD32F4xx\GD32F4xx_board; ..\..\app\Module\Led; ..\..\app\System\Board; ..\..\app\System\Cpu\GD32F4xx; ..\..\app\Module\SmLib; ..\..\app\Module\MPara\lib; ..\..\app\Module\Sample
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FHModule.bin
  ILINK.IlinkOutputFile: GD32F450Z_EVAL.out
  ILINK.IlinkIcfFile: gd32_rom.icf
  ILINK.IlinkAdditionalLibs: ..\..\app\Module\SmLib\libsm4.a; build\Exe\project.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F470xI GD GD32F470xI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__; USE_STDPERIPH_DRIVER; GD32F450
  ICCARM.CCIncludePath2: ..\..\include; Libraries\GD32F4xx_standard_peripheral\Include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; ..\..\components\dfs\filesystems\devfs; ..\..\components\libc\posix\ipc; drivers; ..\..\components\net\lwip\lwip-2.0.3\src\include\netif; Libraries\CMSIS\GD\GD32F4xx\Include; .; ..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\libcpu\arm\cortex-m4; Libraries\CMSIS; ..\..\components\net\sal\include\dfs_net; ..\..\components\dfs\include; ..\..\components\libc\compilers\common\include; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\components\net\lwip\port; ..\..\components\finsh; ..\..\components\net\sal\include\socket\sys_socket; ..\..\components\dfs\filesystems\elmfat; ..\..\components\libc\compilers\common\extension; ..\..\components\net\sal\include; ..\..\components\net\sal\impl; ..\..\components\net\netdev\include; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; ..\..\components\net\sal\include\socket
  OBJCOPY.OOCOutputFile: FHSysmodule.bin
  ILINK.IlinkOutputFile: project.out
  group app/Module/Sample
    ../../app/Module/Sample/: datadeal.c
  group app/System
    ../../app/System/: Algorithm.c TaskFun.c
  group app/System/Cpu
    ../../app/System/Cpu/GD32F4xx/: gd32f4xx_it.c
  group rtos/Drivers
    drivers/: drv_usart.c
