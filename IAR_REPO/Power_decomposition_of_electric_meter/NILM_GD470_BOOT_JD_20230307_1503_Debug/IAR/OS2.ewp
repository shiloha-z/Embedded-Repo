# IAR project OS2.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: GD32F470xI GD GD32F470xI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F470
  ICCARM.CCIncludePath2: ..\app\include; ..\app\CommAPI; ..\app\Config; ..\app\Fal; ..\app\Module\Dbase; ..\app\Module\Events; ..\app\Module\Freeze; ..\app\Module\Led; ..\app\Module\Meter; ..\app\Module\Para; ..\app\Module\Protocol; ..\app\Module\Protocol\dlt645; ..\app\Module\Protocol\DLT698; ..\app\Module\SaveMem; ..\app\Module\Time; ..\app\System; ..\app\System\Cpu\GD32F4xx\CMSIS\GD\GD32F4xx\Include; ..\app\System\Cpu\GD32F4xx\GD32F4xx_board; ..\app\System\Cpu\GD32F4xx\GD32F4xx_standard_peripheral\Include; ..\app\System\Flag; ..\app\System\Cpu\GD32F4xx; ..\app\System\Board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NILM_BOOT.bin
  ILINK.IlinkOutputFile: NILM_BOOT.out
  ILINK.IlinkIcfFile: GD32F450.icf
  ILINK.IlinkAdditionalLibs: FLASH\Exe\OS2.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
