# IAR project f407_5.ewp, settings and files
configuration f407_5 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../X-CUBE-AI/App; ../X-CUBE-AI; ../X-CUBE-AI/Target; ../Middlewares/ST/AI/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: f407_5.hex
  ILINK.IlinkOutputFile: f407_5.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: ai_device_adaptor.c aiPbIO.c aiPbMemRWServices.c aiPbMgr.c aiTestHelper.c aiTestUtility.c aiValidation.c app_x-cube-ai.c lc_print.c network.c network_data.c network_data_params.c pb_common.c pb_decode.c pb_encode.c stm32msg.pb.c syscalls.c
  group Doc
    ../X-CUBE-AI/App/: network_generate_report.txt
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime910_CM4_IAR.a
