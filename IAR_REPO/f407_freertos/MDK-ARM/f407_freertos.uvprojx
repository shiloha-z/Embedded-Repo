# Keil uVision project f407_freertos.uvprojx, settings and files
target f407_freertos (5060960::V5.06 update 7 (build 960)::.\ARMcompiler506)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f407_freertos +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Hardware;../Lvgl;../Lvgl/src;../Lvgl/examples/porting
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Hard/oled
    ../Hardware/: OLED.c
  group LVGL/conf
    ../Lvgl/: lv_conf.h lvgl.h
  group LVGL/porting
    ../Lvgl/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL/src
    ../Lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Lvgl/src/display/: lv_display.c
    ../Lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_hal.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c
    ../Lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ../Lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../Lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../Lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../Lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Lvgl/src/drivers/display/drm/: lv_linux_drm.c
    ../Lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../Lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../Lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../Lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../Lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../Lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../Lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../Lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../Lvgl/src/drivers/evdev/: lv_evdev.c
    ../Lvgl/src/drivers/glfw/: lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c lv_opengles_texture.c
    ../Lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../Lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../Lvgl/src/drivers/qnx/: lv_qnx.c
    ../Lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../Lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c
    ../Lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../Lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../Lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
    ../Lvgl/src/layouts/flex/: lv_flex.c
    ../Lvgl/src/layouts/grid/: lv_grid.c
    ../Lvgl/src/layouts/: lv_layout.c
    ../Lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Lvgl/src/libs/bmp/: lv_bmp.c
    ../Lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../Lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Lvgl/src/libs/libpng/: lv_libpng.c
    ../Lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Lvgl/src/libs/lz4/: lz4.c
    ../Lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Lvgl/src/libs/rle/: lv_rle.c
    ../Lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Lvgl/src/libs/svg/: lv_svg.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ../Lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
    ../Lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c lv_font_manager_utils.c
    ../Lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Lvgl/src/others/gridnav/: lv_gridnav.c
    ../Lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Lvgl/src/others/imgfont/: lv_imgfont.c
    ../Lvgl/src/others/monkey/: lv_monkey.c
    ../Lvgl/src/others/observer/: lv_observer.c
    ../Lvgl/src/others/snapshot/: lv_snapshot.c
    ../Lvgl/src/others/sysmon/: lv_sysmon.c
    ../Lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../Lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Lvgl/src/stdlib/: lv_mem.c
    ../Lvgl/src/themes/default/: lv_theme_default.c
    ../Lvgl/src/themes/mono/: lv_theme_mono.c
    ../Lvgl/src/themes/simple/: lv_theme_simple.c
    ../Lvgl/src/themes/: lv_theme.c
    ../Lvgl/src/tick/: lv_tick.c
    ../Lvgl/src/widgets/animimage/: lv_animimage.c
    ../Lvgl/src/widgets/arc/: lv_arc.c
    ../Lvgl/src/widgets/bar/: lv_bar.c
    ../Lvgl/src/widgets/button/: lv_button.c
    ../Lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Lvgl/src/widgets/chart/: lv_chart.c
    ../Lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Lvgl/src/widgets/image/: lv_image.c
    ../Lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Lvgl/src/widgets/label/: lv_label.c
    ../Lvgl/src/widgets/led/: lv_led.c
    ../Lvgl/src/widgets/line/: lv_line.c
    ../Lvgl/src/widgets/list/: lv_list.c
    ../Lvgl/src/widgets/lottie/: lv_lottie.c
    ../Lvgl/src/widgets/menu/: lv_menu.c
    ../Lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Lvgl/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Lvgl/src/widgets/roller/: lv_roller.c
    ../Lvgl/src/widgets/scale/: lv_scale.c
    ../Lvgl/src/widgets/slider/: lv_slider.c
    ../Lvgl/src/widgets/span/: lv_span.c
    ../Lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Lvgl/src/widgets/spinner/: lv_spinner.c
    ../Lvgl/src/widgets/switch/: lv_switch.c
    ../Lvgl/src/widgets/table/: lv_table.c
    ../Lvgl/src/widgets/tabview/: lv_tabview.c
    ../Lvgl/src/widgets/textarea/: lv_textarea.c
    ../Lvgl/src/widgets/tileview/: lv_tileview.c
    ../Lvgl/src/widgets/win/: lv_win.c
    ../Lvgl/src/: lv_init.c
software components: CMSIS:CORE 4.3.0
